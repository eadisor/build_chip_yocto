#

EXTRA_OEMAKE += " SUNXI_NAND_OOB_SIZE=1280 "